# Keil uVision project EvalBot.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: LM3S9B92 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EvalBot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: RK_Blinky_1LED.s RK_Blinky_2LED_1.2.s RK_PriseEnMain_Moteurs.s Bumper.s Leds.s Switch.s Main.s Moteur.s
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
